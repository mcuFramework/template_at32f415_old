# Keil uVision project template_at32f415.uvprojx, settings and files
target debug (6160000::V6.16::ARMCLANG)
  device: -AT32F415RBT7 ArteryTek
  pack: ArteryTek.AT32F415_DFP.2.0.3
  cpu: IRAM(0x20000000,0x8000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: template_at32f415
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: AT32F415RBT7
  c misc: -fexceptions -frtti
  c include: .\ref\mcuf\src\main;.\ref\core_arterytek_at32f415\src\main;.\ref\driver\src\main;.\src\main;.\src\resource
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group main
    ./src/main/: Main.cpp Lowlevel.cpp
  group main\start
    ./src/main/start/: Entry.cpp Entry.h
  group main\tool
    ./src/main/tool/: BoardPeriph.cpp BoardPeriph.h Console.cpp Console.h package-info.h
  group resource
    ./src/resource/: core_arterytek_interrupt.cpp core_arterytek_interrupt_priority.c core_arterytek_startup.s mcuf_config.h mcuf_lib.cpp rtx_config.h rtx_lib.c
  group library
    ./ref/core_arterytek_at32f415/target/: core_arterytek_at32f415.lib
    ./ref/mcuf/target/: mcuf_m4.lib
    ./ref/driver/target/: driver_m4.lib
